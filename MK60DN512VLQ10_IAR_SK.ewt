<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release_Next</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\Software\App\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Software\App\Module_BSP\Module_BSP.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Software\App\Module_CAN\Module_Can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Software\App\Module_Init\Module_Init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Software\App\Module_ISR\Module_ISR.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Software\App\Module_Protocol\Module_Protocol.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Software\App\Module_Queue\Module_Queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Software\App\Module_IAP\Module_Updata.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Software\App\test.c</name>
    </file>
  </group>
  <group>
    <name>BSP</name>
    <group>
      <name>Devices</name>
      <group>
        <name>inc</name>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Devices\inc\at24cxx.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Devices\inc\IS61WV25616.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Devices\src\at24cxx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Devices\src\IS61WV25616.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>Drivers</name>
      <group>
        <name>inc</name>
      </group>
      <group>
        <name>src</name>
      </group>
    </group>
    <group>
      <name>Library</name>
      <group>
        <name>inc</name>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\adc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\arm_common_tables.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\arm_const_structs.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\arm_math.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\can.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\chlib_k.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\cmp.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\common.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\cpuidy.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\crc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\dac.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\dma.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\dsp_demo.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\enet.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\flash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\flexbus.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\ftm.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\gpio.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\i2c.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\i2s.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\lptmr.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\nfc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\pdb.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\pit.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\rtc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\sd.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\spi.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\SysTick.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\tsi.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\uart.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\vref.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\inc\wdog.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\can.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\cmp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\common.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\cpuidy.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\crc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\dac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\dma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\enet.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\flexbus.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\ftm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\i2c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\i2s.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\lptmr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\nfc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\pdb.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\pit.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\rtc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\sd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\systick.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\tsi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\uart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\vref.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Library\src\wdog.c</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>CPU</name>
    <file>
      <name>$PROJ_DIR$\Software\CPU\CoreSupport\core_cm4.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Software\CPU\DeviceSupport\MK60D10.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Software\CPU\DeviceSupport\IAR-ARM\startup_MK60D10.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Software\CPU\DeviceSupport\system_MK60D10.c</name>
    </file>
  </group>
  <group>
    <name>UCOS-II</name>
    <group>
      <name>uCOSII_Config</name>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\config\includes.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\config\os_cfg.h</name>
      </file>
    </group>
    <group>
      <name>uCOSII_Core</name>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\os_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\os_flag.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\os_mbox.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\os_mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\os_mutex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\os_q.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\os_sem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\os_task.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\os_time.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\os_tmr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\uCOS_II.h</name>
      </file>
    </group>
    <group>
      <name>uCOSII_Port</name>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\port\os_cpu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\port\os_cpu_a_iar.asm</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\port\os_cpu_c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\port\os_dbg.c</name>
      </file>
    </group>
  </group>
</project>


