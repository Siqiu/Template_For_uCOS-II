# IAR project MK60DN512VLQ10_IAR_SK.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MK60D10; RAVEN; DEBUG; UART_USE_DMA; USE_RTOS
  ICCARM.CCDiagSuppress: Pe167,Pa050,Pa082,Pe193,Pe181,Pa091,Pe068
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\INC\c; Software\App; Software\BSP\Devices\src; Software\BSP\Devices\inc; Software\BSP\Library\src; Software\BSP\Library\inc; Software\CPU\CoreSupport; Software\CPU\DeviceSupport; Software\uCOS-II\config; Software\uCOS-II\core; Software\uCOS-II\port; Software\App\Module_CAN; Software\App\Module_Protocol; Software\App\Module_Init; Software\App\Module_BSP; Software\App\Module_ISR; Software\App\Module_Queue; Software\App\Module_IAP; Software\App\Module_Modbus; Software\App\Module_USB; Software\App\Module_malloc; Software\App\Module_log; Software\App\Module_NET; Software\emWin\Include; Software\emWin\Lib; Software\emWin\Sample\Config; Software\emWin\Sample\GUIDemo; Software\BSP\Library\inc; Software\lwip; Software\lwip\arch; Software\lwip\src\include; Software\lwip\src\include\ipv4; Software\USBStack\port_templete; Software\USBStack\src; Software\USBStack\inc; Software\fatfs
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template_For_uCOS-II.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: Software\LinkFiles\K60\MK60xN512_10.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: MK60D10; RAVEN; UART_USE_DMA; USE_BOOT_EN; USE_RTOS
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\INC\c; Software\App; Software\BSP\Devices\src; Software\BSP\Devices\inc; Software\BSP\Library\src; Software\BSP\Library\inc; Software\CPU\CoreSupport; Software\CPU\DeviceSupport; Software\uCOS-II\config; Software\uCOS-II\core; Software\uCOS-II\port; Software\App\Module_CAN; Software\App\Module_Protocol; Software\App\Module_Init; Software\App\Module_BSP; Software\App\Module_ISR; Software\App\Module_Queue; Software\App\Module_IAP; Software\App\Module_Modbus; Software\App\Module_USB; Software\App\Module_malloc; Software\App\Module_log; Software\emWin\Include; Software\emWin\Lib; Software\emWin\Sample\Config; Software\emWin\Sample\GUIDemo; Software\BSP\Library\inc; Software\lwip; Software\lwip\arch; Software\lwip\lwip-1.4.1\include; Software\lwip\lwip-1.4.1\include\ipv4; Software\USBStack\port_templete; Software\USBStack\src; Software\USBStack\inc; Software\fatfs
  ICCARM.CCOptLevel: 1
  ILINK.IlinkIcfFile: Software\LinkFiles\K60\MK60xN512_10_APP1.icf
configuration Release_Next (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: MK60D10; RAVEN; UART_USE_DMA; USE_BOOT_EN
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\INC\c; Software\App; Software\BSP\Devices\src; Software\BSP\Devices\inc; Software\BSP\Library\src; Software\BSP\Library\inc; Software\CPU\CoreSupport; Software\CPU\DeviceSupport; Software\uCOS-II\config; Software\uCOS-II\core; Software\uCOS-II\port; Software\App\Module_CAN; Software\App\Module_Protocol; Software\App\Module_Init; Software\App\Module_BSP; Software\App\Module_ISR; Software\App\Module_Queue; Software\App\Module_IAP; Software\App\Module_Modbus; Software\App\Module_USB; Software\emWin\Include; Software\emWin\Lib; Software\emWin\Sample\Config; Software\emWin\Sample\GUIDemo; Software\BSP\Library\inc; Software\lwip; Software\lwip\arch; Software\lwip\lwip-1.4.1\include; Software\lwip\lwip-1.4.1\include\ipv4; Software\USBStack\port_templete; Software\USBStack\src; Software\USBStack\inc
  ICCARM.CCOptLevel: 1
  ILINK.IlinkIcfFile: Software\LinkFiles\K60\MK60xN512_10_APP2.icf
  group App
    Software/uCOS-II/config/: includes.h
    Software/App/: main.c test.c
    Software/App/Module_BSP/: Module_BSP.c
    Software/App/Module_CAN/: Module_Can.c
    Software/App/Module_Init/: Module_Init.c
    Software/App/Module_ISR/: Module_ISR.c
    Software/App/Module_log/: Module_log.c
    Software/App/Module_malloc/: Module_malloc.c
    Software/App/Module_Modbus/: Module_Modbus.c
    Software/App/Module_Protocol/: Module_Protocol.c
    Software/App/Module_Queue/: Module_Queue.c
    Software/App/Module_NET/: Module_tcp.c Module_udp.c
    Software/App/Module_IAP/: Module_Updata.c
    Software/App/Module_USB/: Module_USB.c
  group BSP/Devices/inc
    Software/BSP/Devices/inc/: at24cxx.h ili9320.h IS61WV25616.h
  group BSP/Devices/src
    Software/BSP/Devices/src/: at24cxx.c enet_phy.c ili9320.c IS61WV25616.c
    Software/App/: drv_enet.c
  group BSP/Library
    Software/BSP/Library/src/: can.c common.c cpuidy.c crc.c dma.c enet.c flash.c flexbus.c gpio.c i2c.c pit.c rtc.c sd.c spi.c systick.c uart.c wdog.c
  group CPU
    Software/CPU/CoreSupport/: core_cm4.h
    Software/CPU/DeviceSupport/: MK60D10.h system_MK60D10.c
    Software/CPU/DeviceSupport/IAR-ARM/: startup_MK60D10.s
  group Fatfs
    Software/fatfs/option/: cc936.c
    Software/fatfs/: diskio.c ff.c ffconf.h
  group Lwip/lwip_api
    Software/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Lwip/lwip_arch
    Software/lwip/arch/: sys_arch.c
  group Lwip/lwip_core
    Software/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
    Software/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    Software/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group Lwip/lwip_netif
    Software/lwip/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
    Software/lwip/src/netif/: etharp.c ethernetif.c slipif.c
  group UCOS-II/uCOSII_Config
    Software/uCOS-II/config/: os_cfg.h
  group UCOS-II/uCOSII_Core
    Software/uCOS-II/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c uCOS_II.h
  group UCOS-II/uCOSII_Port
    Software/uCOS-II/port/: os_cpu.h os_cpu_a_iar.asm os_cpu_c.c os_dbg.c
  group USB-Stack/USB-Config
    Software/USBStack/port_templete/: usb_config.h usb_lib.c
  group USB-Stack/USB-Lib
    Software/USBStack/src/: usbd_cdc_acm.c usbd_core.c usbd_core_cdc.c usbd_core_hid.c usbd_core_msc.c usbd_hid.c usbd_kk.c usbd_msc.c
