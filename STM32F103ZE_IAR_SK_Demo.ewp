# IAR project STM32F103ZE_IAR_SK_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MK60D10; RAVEN; DEBUG
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: Software\App; Software\BSP\Drive\src; Software\BSP\Drive\inc; Software\CPU\CoreSupport; Software\CPU\DeviceSupport; Software\uCOS-II\config; Software\uCOS-II\core; Software\uCOS-II\port; $TOOLKIT_DIR$\INC\c
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template_For_uCOS-II.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group App
    Software/App/: main.c
  group BSP/Drive/inc
    Software/BSP/Drive/inc/: adc.h arm_common_tables.h arm_const_structs.h arm_math.h can.h chlib_k.h cmp.h common.h cpuidy.h crc.h dac.h dma.h dsp_demo.h enet.h flash.h flexbus.h ftm.h gpio.h i2c.h i2s.h lptmr.h nfc.h pdb.h pit.h rtc.h sd.h spi.h SysTick.h tsi.h uart.h vref.h wdog.h
  group BSP/Drive/src
    Software/BSP/Drive/src/: adc.c can.c cmp.c common.c cpuidy.c crc.c dac.c dma.c enet.c flash.c flexbus.c ftm.c gpio.c i2c.c i2s.c lptmr.c nfc.c pdb.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c vref.c wdog.c
  group CPU
    Software/CPU/DeviceSupport/IAR-ARM/: startup_MK60D10.s
    Software/CPU/DeviceSupport/: system_MK60D10.c
  group UCOS-II/uCOSII_Config
    Software/uCOS-II/config/: includes.h os_cfg.h
  group UCOS-II/uCOSII_Core
    Software/uCOS-II/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c uCOS_II.h
  group UCOS-II/uCOSII_Port
    Software/uCOS-II/port/: os_cpu.h os_cpu_a_iar.asm os_cpu_c.c os_dbg.c
