<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM32F103ZE-SK</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\Software\App\main.c</name>
    </file>
  </group>
  <group>
    <name>BSP</name>
    <group>
      <name>Drive</name>
      <group>
        <name>inc</name>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\adc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\arm_common_tables.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\arm_const_structs.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\arm_math.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\can.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\chlib_k.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\cmp.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\common.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\cpuidy.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\crc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\dac.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\dma.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\dsp_demo.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\enet.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\flash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\flexbus.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\ftm.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\gpio.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\i2c.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\i2s.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\lptmr.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\nfc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\pdb.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\pit.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\rtc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\sd.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\spi.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\SysTick.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\tsi.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\uart.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\vref.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\inc\wdog.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\can.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\cmp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\common.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\cpuidy.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\crc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\dac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\dma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\enet.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\flexbus.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\ftm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\i2c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\i2s.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\lptmr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\nfc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\pdb.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\pit.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\rtc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\sd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\systick.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\tsi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\uart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\vref.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Software\BSP\Drive\src\wdog.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>Library</name>
      <group>
        <name>inc</name>
      </group>
      <group>
        <name>src</name>
      </group>
    </group>
  </group>
  <group>
    <name>CPU</name>
    <file>
      <name>$PROJ_DIR$\Software\CPU\DeviceSupport\IAR-ARM\startup_MK60D10.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Software\CPU\DeviceSupport\system_MK60D10.c</name>
    </file>
  </group>
  <group>
    <name>UCOS-II</name>
    <group>
      <name>uCOSII_Config</name>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\config\includes.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\config\os_cfg.h</name>
      </file>
    </group>
    <group>
      <name>uCOSII_Core</name>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\os_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\os_flag.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\os_mbox.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\os_mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\os_mutex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\os_q.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\os_sem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\os_task.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\os_time.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\os_tmr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\core\uCOS_II.h</name>
      </file>
    </group>
    <group>
      <name>uCOSII_Port</name>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\port\os_cpu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\port\os_cpu_a_iar.asm</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\port\os_cpu_c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Software\uCOS-II\port\os_dbg.c</name>
      </file>
    </group>
  </group>
</project>


