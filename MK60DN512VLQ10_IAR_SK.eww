<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MK60DN512VLQ10_IAR_SK.ewp</path>
  </project>
  <batchBuild/>
</workspace>


